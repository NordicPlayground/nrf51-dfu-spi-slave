# Keil uVision project dfu_single_bank_serial_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4
  c define: __HEAP_SIZE=0 BOARD_PCA10028 S110 BSP_DEFINES_ONLY NRF51  SWI_DISABLE0 DFU_256K
  c misc: --c99
  c include: ..\..\..\config\dfu_single_bank_serial_s110_pca10028;..\..\..\config;..\..\..\..\components_modified\bootloader_dfu\hci_transport;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\hci\config;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\;..\..\..\..\components_modified\bootloader_dfu
  library: MicroLIB
  memory RVCT4: ROM 0x3d000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/spi_slave/: spi_slave.c
    ../../../: nrf_flash.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../../components/libraries/bootloader_dfu/: bootloader_settings.c bootloader_util.c dfu_init_template.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/hci/: hci_mem_pool.c
    ../../../: spi_slave_com_interface.c dfu_transport_spi_slave.c app_scheduler_mod.c
    ../../../../components_modified/bootloader_dfu/: bootloader.c dfu_single_bank.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
software components: CMSIS:CORE 3.40.0, Device:Startup 7.2.1
